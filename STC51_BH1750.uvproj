# Keil uVision project STC51_BH1750.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: STC51_BH1750 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 STC_BH1750.c 12864.c main.c GPES.c DHT11.c send_all.c key.c start.c tu.c
